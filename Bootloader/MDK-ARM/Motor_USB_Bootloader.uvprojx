# Keil uVision project Motor_USB_Bootloader.uvprojx, settings and files
target Motor_USB_Bootloader (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x8005BFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Motor_USB_Bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../../Application/Core/Inc;../../Application/Drivers/STM32F1xx_HAL_Driver/Inc;../../Application/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../Application/Drivers/CMSIS/Include;../../Application/Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../Application/USB_DEVICE/App;../../Application/USB_DEVICE/Target;../../Application/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../Application/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x5c00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USB Bootloader
    ../Src/: boot_main.c boot_protocol.c
    ../../Application/MDK-ARM/: startup_stm32f103xb.s
    ../../Application/Core/Src/: system_stm32f1xx.c
    ../../Application/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
    ../../Application/USB_DEVICE/App/: usb_device.c usbd_desc.c
    ../../Application/USB_DEVICE/Target/: usbd_conf.c
    ../../Application/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../Application/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.3.0
